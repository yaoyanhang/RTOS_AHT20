# Keil uVision project RTOS_AHT20.uvprojx, settings and files
target RTOS_AHT20 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS_AHT20 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\uCOS_III\uCOS_CONFIG;..\uCOS_III\uCOS_CPU;..\uCOS_III\uCOS_CPU\ARM-Cortex-M3\RealView;..\uCOS_III\uCOS_III\Ports\ARM-Cortex-M3\Generic\RealView;..\uCOS_III\uCOS_III\Source;..\uCOS_III\uCOS_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application
    ../Core/Src/: main.c app.c aht20.c bsp_i2c.c bsp_uart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Startup
    ./: startup_stm32f103xb.s
  group uCOS_III_CONFIG
    ../uCOS_III/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h os_cfg_app.h
  group uCOS_III_CPU
    ../uCOS_III/uCOS_CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uCOS_III/uCOS_CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uCOS_III_LIB
    ../uCOS_III/uCOS_LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS_III_PORT
    ../uCOS_III/uCOS_III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS_III_SOURCE
    ../uCOS_III/uCOS_III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
